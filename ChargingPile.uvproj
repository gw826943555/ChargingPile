# Keil uVision project ChargingPile.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: ChargingPile +hex
  c flags: SizeSpeed=1
  group User
    ./: main2.c uart.c ADC.c globaldata.c timer.c DIO.c
